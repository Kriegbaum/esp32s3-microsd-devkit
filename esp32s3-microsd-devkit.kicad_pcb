# Repository Kriegbaum/esp32s3-microsd-devkit

## KiCad design esp32s3-microsd-devkit.kicad_pcb

Parts:
C6: CL21B104KBCNNNC; 0805_cap; Tolerance 10%; Voltage 50v
C7: CL21A106KOQNNNE; 0805_cap; Tolerance 20%; Voltage 16v
C8: CL21B105KBFNNNG; 0805_cap; Tolerance 10%; Voltage 50v
D1: LTST-C170KFKT; LED_0805_2012Metric_Pad1.15x1.40mm_HandSolder; Forward Voltage 2V
J1, J3: Conn_01x17; PinHeader_1x17_P2.54mm_Vertical
R5: RC0805JR-0710KL; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
R6: RNCP0805FTD1K00; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
U1: ESP32-S3-WROOM-1

Connections:
+3.3V: C6.1, C7.1, J1.14, J1.16, J3.2, R5.2, R6.2, U1.2 (3V3); also elsewhere on the board
+5V: J3.1; also elsewhere on the board
/Reset Boot Buttons/BOOT_BUTTON: U1.27 (IO0); also elsewhere on the board
/Reset Boot Buttons/RESET_BUTTON: C8.1, R5.1, U1.3 (EN); also elsewhere on the board
/SD Card/SD_CLK: U1.6 (IO6); also elsewhere on the board
/SD Card/SD_CMD: U1.7 (IO7); also elsewhere on the board
/SD Card/SD_D0: U1.5 (IO5); also elsewhere on the board
/SD Card/SD_D1: U1.4 (IO4); also elsewhere on the board
/SD Card/SD_D2: U1.9 (IO16); also elsewhere on the board
/SD Card/SD_D3: U1.8 (IO15); also elsewhere on the board
/USB C/USB_D+: U1.14 (IO20); also elsewhere on the board
/USB C/USB_D-: U1.13 (IO19); also elsewhere on the board
GND: C6.2, C7.2, C8.2, D1.1 (K), J1.15, J1.17, J3.3, U1.1 (GND), U1.40 (GND), U1.41 (GND); also elsewhere on the board
GPIO_1: J1.1, U1.39 (IO1)
GPIO_2: J1.2, U1.38 (IO2)
GPIO_3: J3.7, U1.15 (IO3)
GPIO_8: J3.6, U1.12 (IO8)
GPIO_9: J3.9, U1.17 (IO9)
GPIO_10: J3.10, U1.18 (IO10)
GPIO_11: J3.11, U1.19 (IO11)
GPIO_12: J3.12, U1.20 (IO12)
GPIO_13: J3.13, U1.21 (IO13)
GPIO_14: J3.14, U1.22 (IO14)
GPIO_17: J3.4, U1.10 (IO17)
GPIO_18: J3.5, U1.11 (IO18)
GPIO_21: J3.15, U1.23 (IO21)
GPIO_35: J1.12, U1.28 (IO35)
GPIO_36: J1.11, U1.29 (IO36)
GPIO_37: J1.10, U1.30 (IO37)
GPIO_38: J1.9, U1.31 (IO38)
GPIO_39: J1.8, U1.32 (IO39)
GPIO_40: J1.7, U1.33 (IO40)
GPIO_41: J1.6, U1.34 (IO41)
GPIO_42: J1.5, U1.35 (IO42)
GPIO_45: J1.13, U1.26 (IO45)
GPIO_46: J3.8, U1.16 (IO46)
GPIO_47: J3.16, U1.24 (IO47)
GPIO_48: J3.17, U1.25 (IO48)
unnamed: D1.2 (A), R6.1
RXD0: J1.4, U1.36 (RXD0)
TXD0: J1.3, U1.37 (TXD0)

Notes on the sheet:
Power Indicator

Parts:
C2: CL21B104KBCNNNC; 0805_cap; Tolerance 10%; Voltage 50v
C4, C5: CL21A475KAQNNNE; 0805_cap; Tolerance 10%; Voltage 25v
C9: CL21A106KOQNNNE; 0805_cap; Tolerance 20%; Voltage 16v
D2: MBR230LS; D_SOD-123; Forward Voltage 500mV; Voltage 40V
H1, H2, H3: MountingHole; MountingHole_2.2mm_M2_ISO7380_Pad
J2: USB4105-GF-A; USB_C_Receptacle_GCT_USB4105-xx-A_16P_TopMnt_Horizontal
L1: NRS3015T1R0NNGHV; IND_NRS3015T100MNGHV_TAY; Manufacturer_Part_Number NR4018T4R7M; Mouser Part Number 963-NR4018T4R7M
R3, R4: RC0805FR-075K1L; R_0805_2012Metric_Pad1.20x1.40mm_HandSolder
TP1, TP2, TP3: TestPoint; TestPoint_Pad_1.5x1.5mm
U2: USBLC6-2P6; SOT-666
U3: MIC23150-SYMT-TR; MLF-8_MT_MCH

Connections:
+3.3V: C5.1, L1.2, TP1.1, U3.4 (SNS); also elsewhere on the board
+5V: C2.1, C4.1, C9.2, D2.1 (K), TP2.1, U2.5 (VBUS), U3.3 (EN), U3.6 (VIN), U3.7 (VIN); also elsewhere on the board
/USB C/USB_D+: U2.4 (I/O2); also elsewhere on the board
/USB C/USB_D-: U2.6 (I/O1); also elsewhere on the board
GND: C2.2, C4.2, C5.2, C9.1, J2.A1 (GND), J2.A12 (GND), J2.B1 (GND), J2.B12 (GND), J2.S1 (SHIELD), R3.2, R4.2, TP3.1, U2.2 (GND), U3.5 (AGND), U3.8 (PGND); also elsewhere on the board
unnamed: D2.2 (A), J2.A4 (VBUS), J2.A9 (VBUS), J2.B4 (VBUS), J2.B9 (VBUS)
unnamed: J2.A5 (CC1), R4.1
unnamed: J2.B5 (CC2), R3.1
unnamed: J2.A6 (D+), J2.B6 (D+), U2.3 (I/O2)
unnamed: J2.A7 (D-), J2.B7 (D-), U2.1 (I/O1)
unnamed: L1.1, U3.1 (SW), U3.2 (SW)

Parts:
BOOT1: PTS830GG140GSMTRLFS; Manufacturer_Part_Number PTS830GG140GSMTRLFS; Mouser Part Number 611-PTS830GG140GSMTR
C10, C11: CL21B104KBCNNNC; 0805_cap; Tolerance 10%; Voltage 50v
RESET1: PTS830GG140GSMTRLFS; Manufacturer_Part_Number PTS830GG140GSMTRLFS; Mouser Part Number 611-PTS830GG140GSMTR

Connections:
/Reset Boot Buttons/BOOT_BUTTON: BOOT1.1 (NO_1), BOOT1.2 (NO_2), C11.1; also elsewhere on the board
/Reset Boot Buttons/RESET_BUTTON: C10.1, RESET1.1 (NO_1), RESET1.2 (NO_2); also elsewhere on the board
GND: BOOT1.3 (COM_1), BOOT1.4 (COM_2), BOOT1.5 (GND), BOOT1.6 (GND), C10.2, C11.2, RESET1.3 (COM_1), RESET1.4 (COM_2), RESET1.5 (GND), RESET1.6 (GND); also elsewhere on the board

Parts:
C1: CL21A106KOQNNNE; 0805_cap; Tolerance 20%; Voltage 16v
C3: CL21B104KBCNNNC; 0805_cap; Tolerance 10%; Voltage 50v
R1, R2: YC124-JR-0747KL; Resistor_Array_0805_x4
X1: DM3AT-SF-PEJM5

Connections:
+3.3V: C1.1, C3.1, R1.5 (R4), R1.6 (R3), R1.7 (R2), R1.8 (R1), R2.5 (R4), R2.6 (R3), R2.7 (R2), R2.8 (R1), X1.4 (VDD); also elsewhere on the board
/SD Card/SD_CLK: R1.4 (R4), X1.5 (CLK); also elsewhere on the board
/SD Card/SD_CMD: R1.3 (R3), X1.3 (CMD); also elsewhere on the board
/SD Card/SD_D0: R2.1 (R1), X1.7 (DAT0); also elsewhere on the board
/SD Card/SD_D1: R2.2 (R2), X1.8 (DAT1); also elsewhere on the board
/SD Card/SD_D2: R1.1 (R1), X1.1 (DAT2); also elsewhere on the board
/SD Card/SD_D3: R1.2 (R2), X1.2 (CD/DAT3); also elsewhere on the board
GND: C1.2, C3.2, X1.6 (GND), X1.P1 (SHIELD), X1.P2 (SHIELD), X1.P3 (SHIELD), X1.P4 (SHIELD), X1.SWA; also elsewhere on the board

Board: 4 copper layers, 54.4 x 53.3 mm, 35 parts (2 on the bottom side), 47 nets.

## Commit log

2023-07-23 Ready to make v0.1
2023-08-03 Fix cross-wired USB lines
2023-08-04 Fix diode part number
2023-08-10 Update diode reference
2023-08-10 Update gitignore
